v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
F {}
E {}
N -2150 -410 -2150 -370 {lab=iv2}
N -1470 -410 -1470 -370 {lab=iv1}
N -2150 -310 -2150 -270 {lab=IO_vss}
N -1470 -310 -1470 -270 {lab=IO_vss}
N -2150 -180 -2150 -140 {lab=iv0}
N -2150 -80 -2150 -40 {lab=IO_vss}
N -2150 -660 -2150 -620 {lab=iv4}
N -1470 -660 -1470 -620 {lab=iv3}
N -1470 -560 -1470 -520 {lab=IO_vss}
N -1340 -990 -1340 -960 {lab=vcont}
N -1340 -900 -1340 -870 {lab=GND}
N 70 -660 220 -660 {lab=IO_vdd}
N 20 -680 240 -680 {lab=IO_iovss}
N 60 -200 240 -200 {lab=IO_iovss}
N 70 -190 250 -190 {lab=IO_iovdd}
N -230 -670 -230 -200 {lab=IO_iovss}
N -240 -680 -240 -190 {lab=IO_iovdd}
N 60 -670 230 -670 {lab=IO_vss}
N -210 -620 -210 -220 {lab=IO_vdd}
N -220 -210 -60 -210 {lab=IO_vss}
N 240 -490 240 -200 {lab=IO_iovss}
N 220 -370 220 -220 {lab=IO_vdd}
N -520 -1000 -520 -990 {
lab=IO_iovdd}
N -720 -1000 -720 -990 {
lab=IO_iovss}
N 10 -720 10 -690 {lab=IO_iovdd}
N -70 -690 10 -690 {lab=IO_iovdd}
N 20 -720 20 -680 {lab=IO_iovss}
N -60 -680 20 -680 {lab=IO_iovss}
N 60 -720 60 -670 {lab=IO_vss}
N -20 -670 60 -670 {lab=IO_vss}
N 70 -720 70 -660 {lab=IO_vdd}
N 40 -690 250 -690 {lab=IO_iovdd}
N 70 -190 70 -160 {lab=IO_iovdd}
N -10 -190 70 -190 {lab=IO_iovdd}
N 60 -200 60 -160 {lab=IO_iovss}
N 40 -200 60 -200 {lab=IO_iovss}
N 10 -220 10 -160 {lab=IO_vdd}
N -70 -220 10 -220 {lab=IO_vdd}
N 40 -960 90 -960 {lab=IO_iovdd}
N 40 -980 40 -960 {lab=IO_iovdd}
N 40 -960 40 -690 {lab=IO_iovdd}
N 10 -690 40 -690 {lab=IO_iovdd}
N -70 -720 -70 -690 {lab=IO_iovdd}
N -240 -690 -70 -690 {lab=IO_iovdd}
N -60 -720 -60 -680 {lab=IO_iovss}
N -230 -680 -60 -680 {lab=IO_iovss}
N -20 -720 -20 -670 {lab=IO_vss}
N -220 -670 -20 -670 {lab=IO_vss}
N -10 -720 -10 -660 {lab=IO_vdd}
N -40 -960 -40 -660 {lab=IO_vdd}
N -210 -660 -40 -660 {lab=IO_vdd}
N -580 -1000 -580 -990 {
lab=IO_vdd}
N -660 -1000 -660 -990 {
lab=IO_vss}
N -10 -190 -10 -160 {lab=IO_iovdd}
N -240 -190 -10 -190 {lab=IO_iovdd}
N -20 -200 -20 -160 {lab=IO_iovss}
N -60 -210 -60 -160 {lab=IO_vss}
N -70 -220 -70 -160 {lab=IO_vdd}
N -210 -220 -70 -220 {lab=IO_vdd}
N -100 -960 -40 -960 {lab=IO_vdd}
N -40 -980 -40 -960 {lab=IO_vdd}
N 40 100 40 120 {lab=IO_iovss}
N -40 100 -40 120 {lab=IO_vss}
N 40 100 100 100 {lab=IO_iovss}
N 40 -200 40 100 {lab=IO_iovss}
N -100 100 -40 100 {lab=IO_vss}
N 10 -220 220 -220 {lab=IO_vdd}
N 250 -500 250 -190 {lab=IO_iovdd}
N 250 -500 300 -500 {lab=IO_iovdd}
N 250 -690 250 -500 {lab=IO_iovdd}
N 240 -490 300 -490 {lab=IO_iovss}
N 240 -680 240 -490 {lab=IO_iovss}
N 230 -450 300 -450 {lab=IO_vss}
N 230 -670 230 -450 {lab=IO_vss}
N 220 -440 300 -440 {lab=IO_vdd}
N -360 -680 -240 -680 {lab=IO_iovdd}
N -240 -690 -240 -680 {lab=IO_iovdd}
N -360 -360 -360 -280 {lab=IO_iovdd}
N -380 -680 -360 -680 {lab=IO_iovdd}
N -380 -280 -360 -280 {lab=IO_iovdd}
N -380 -360 -360 -360 {lab=IO_iovdd}
N -360 -440 -360 -360 {lab=IO_iovdd}
N -380 -440 -360 -440 {lab=IO_iovdd}
N -360 -520 -360 -440 {lab=IO_iovdd}
N -380 -520 -360 -520 {lab=IO_iovdd}
N -360 -600 -360 -520 {lab=IO_iovdd}
N -380 -600 -360 -600 {lab=IO_iovdd}
N -360 -680 -360 -600 {lab=IO_iovdd}
N -350 -670 -230 -670 {lab=IO_iovss}
N -230 -680 -230 -670 {lab=IO_iovss}
N -350 -350 -350 -270 {lab=IO_iovss}
N -380 -670 -350 -670 {lab=IO_iovss}
N -380 -270 -350 -270 {lab=IO_iovss}
N -380 -590 -350 -590 {lab=IO_iovss}
N -350 -670 -350 -590 {lab=IO_iovss}
N -380 -510 -350 -510 {lab=IO_iovss}
N -350 -590 -350 -510 {lab=IO_iovss}
N -380 -430 -350 -430 {lab=IO_iovss}
N -350 -510 -350 -430 {lab=IO_iovss}
N -380 -350 -350 -350 {lab=IO_iovss}
N -350 -430 -350 -350 {lab=IO_iovss}
N -340 -630 -220 -630 {lab=IO_vss}
N -220 -670 -220 -630 {lab=IO_vss}
N -340 -310 -340 -230 {lab=IO_vss}
N -380 -630 -340 -630 {lab=IO_vss}
N -380 -230 -340 -230 {lab=IO_vss}
N -380 -550 -340 -550 {lab=IO_vss}
N -340 -630 -340 -550 {lab=IO_vss}
N -380 -470 -340 -470 {lab=IO_vss}
N -340 -550 -340 -470 {lab=IO_vss}
N -380 -390 -340 -390 {lab=IO_vss}
N -340 -470 -340 -390 {lab=IO_vss}
N -380 -310 -340 -310 {lab=IO_vss}
N -340 -390 -340 -310 {lab=IO_vss}
N -330 -620 -210 -620 {lab=IO_vdd}
N -210 -660 -210 -620 {lab=IO_vdd}
N -330 -300 -330 -220 {lab=IO_vdd}
N -380 -620 -330 -620 {lab=IO_vdd}
N -380 -220 -330 -220 {lab=IO_vdd}
N -380 -540 -330 -540 {lab=IO_vdd}
N -330 -620 -330 -540 {lab=IO_vdd}
N -380 -460 -330 -460 {lab=IO_vdd}
N -330 -540 -330 -460 {lab=IO_vdd}
N -380 -380 -330 -380 {lab=IO_vdd}
N -330 -460 -330 -380 {lab=IO_vdd}
N -380 -300 -330 -300 {lab=IO_vdd}
N -330 -380 -330 -300 {lab=IO_vdd}
N -380 -650 -300 -650 {lab=pv4}
N -380 -570 -300 -570 {lab=pv3}
N -380 -490 -300 -490 {lab=pv2}
N -380 -410 -300 -410 {lab=pv1}
N -380 -330 -300 -330 {lab=pv0}
N -750 -650 -620 -650 {lab=iv4}
N -750 -570 -620 -570 {lab=iv3}
N -750 -490 -620 -490 {lab=iv2}
N -750 -410 -620 -410 {lab=iv1}
N -750 -330 -620 -330 {lab=iv0}
N -750 -250 -620 -250 {lab=vcont}
N -230 -200 -20 -200 {lab=IO_iovss}
N -40 -210 -40 100 {lab=IO_vss}
N -60 -210 -40 -210 {lab=IO_vss}
N 20 -210 20 -160 {lab=IO_vss}
N -2150 -560 -2150 -520 {lab=IO_vss}
N -220 -630 -220 -210 {lab=IO_vss}
N 230 -360 230 -210 {lab=IO_vss}
N 560 -390 560 -360 {lab=IO_vss}
N 230 -360 560 -360 {lab=IO_vss}
N 230 -450 230 -360 {lab=IO_vss}
N -190 -450 -140 -450 {lab=pv4,pv3,pv2,pv1,pv0}
N -190 -420 -140 -420 {lab=#net1}
N -380 -250 -190 -250 {lab=#net1}
N -0 -210 20 -210 {lab=IO_vss}
N -40 -660 -10 -660 {lab=IO_vdd}
N 200 -370 220 -370 {lab=IO_vdd}
N 220 -440 220 -370 {lab=IO_vdd}
N 160 -210 230 -210 {lab=IO_vss}
N -20 -200 40 -200 {lab=IO_iovss}
N 220 -660 220 -440 {lab=IO_vdd}
N 180 -470 300 -470 {lab=vout}
N 0 -660 70 -660 {lab=IO_vdd}
N -190 -620 -190 -450 {lab=pv4,pv3,pv2,pv1,pv0}
N 180 -480 180 -470 {lab=vout}
N -190 -420 -190 -250 {lab=#net1}
N 160 -470 180 -470 {lab=vout}
N 160 -470 160 -420 {lab=vout}
N 120 -470 160 -470 {lab=vout}
N 90 -370 120 -370 {lab=IO_vss}
N 90 -370 90 -210 {lab=IO_vss}
N 20 -210 90 -210 {lab=IO_vss}
N 160 -230 160 -210 {lab=IO_vss}
N 90 -210 160 -210 {lab=IO_vss}
N 160 -300 160 -290 {lab=#net2}
N 0 -370 -0 -210 {lab=IO_vss}
N -40 -210 -0 -210 {lab=IO_vss}
N 0 -660 0 -570 {lab=IO_vdd}
N -10 -660 0 -660 {lab=IO_vdd}
C {devices/vsource.sym} -1470 -340 0 0 {name=Vdd9 value="dc 0 ac 0 pulse(0, \{\{b1\}*3.3\}, 0,\{SR_control\},\{SR_control\}, \{2*\{TIME_fase\}\}, \{4*\{TIME_fase\}\})"}
C {devices/vsource.sym} -2150 -340 0 0 {name=Vdd10 value="dc 0 ac 0 pulse(0, \{\{b2\}*3.3\}, 0,\{SR_control\},\{SR_control\}, \{4*\{TIME_fase\}\}, \{8*\{TIME_fase\}\}) "}
C {devices/lab_pin.sym} -2150 -410 0 0 {name=p49 sig_type=std_logic lab=iv2}
C {devices/lab_pin.sym} -1470 -410 0 0 {name=p50 sig_type=std_logic lab=iv1}
C {devices/lab_pin.sym} -2150 -270 2 0 {name=p51 sig_type=std_logic lab=IO_vss}
C {devices/lab_pin.sym} -1470 -270 2 0 {name=p52 sig_type=std_logic lab=IO_vss}
C {devices/vsource.sym} -2150 -110 0 0 {name=Vdd11 value="dc 0 ac 0 pulse(0, \{\{b0\}*3.3\}, 0,\{SR_control\},\{SR_control\}, \{TIME_fase\}, \{2*\{TIME_fase\}\})"}
C {devices/lab_pin.sym} -2150 -180 0 0 {name=p53 sig_type=std_logic lab=iv0}
C {devices/lab_pin.sym} -2150 -40 2 0 {name=p54 sig_type=std_logic lab=IO_vss}
C {devices/vsource.sym} -1470 -590 0 0 {name=Vdd1 value="dc 0 ac 0 pulse(0, \{\{b3\}*3.3\}, 0,\{SR_control\},\{SR_control\}, \{8*\{TIME_fase\}\}, \{16*\{TIME_fase\}\})"}
C {devices/vsource.sym} -2150 -590 0 0 {name=Vdd2 value="dc 0 ac 0 pulse(0, \{\{b4\}*3.3\}, 0,\{SR_control\},\{SR_control\}, \{16*\{TIME_fase\}\}, \{32*\{TIME_fase\}\}) "}
C {devices/lab_pin.sym} -2150 -660 0 0 {name=p11 sig_type=std_logic lab=iv4}
C {devices/lab_pin.sym} -1470 -660 0 0 {name=p10 sig_type=std_logic lab=iv3}
C {devices/lab_pin.sym} -2150 -520 2 0 {name=p2 sig_type=std_logic lab=IO_vss}
C {devices/lab_pin.sym} -1470 -520 2 0 {name=p9 sig_type=std_logic lab=IO_vss}
C {devices/lab_pin.sym} -190 -620 2 0 {name=p30 sig_type=std_logic lab="pv4,pv3,pv2,pv1,pv0"}
C {devices/lab_pin.sym} -1340 -990 2 0 {name=p12 sig_type=std_logic lab=vcont}
C {devices/vsource.sym} -1340 -930 0 0 {name=Vdd4 value=0.9 savecurrent=false
}
C {devices/gnd.sym} -1340 -870 0 0 {name=l9 lab=GND}
C {netlist_not_shown.sym} -1400 -800 0 0 {name=s1 only_toplevel=true 

value="

* Circuit Parameters
.param vdd = 1.2
.param vss = 0.0
.param b0 = 0
.param b1 = 0
.param b2 = 0
.param b3 = 0
.param b4 = 0
.param SR_control=110p
.param TIME_fase= 20n
.param SR_clk=25p
.param T_clk=500p
.options TEMP = 27.0
.OPTION RSHUNT=1e7
.OPTION CSHUNT=1e-15
.option rseries = 1e-4
.option ITL1 = 200
.option ITL2 = 600
.options method=gear reltol=1e-2 abstol=1e-3 vntol=1e-4
.options gmin=3e-8


* 	Initial Conditions
* Inputs and IOCells
.nodeset v(iv0)=0 v(iv1)=0 v(iv2)=0 v(iv3)=0 v(iv4)=0
.nodeset v(vcont)=0.9
.nodeset v(pv0)=0 v(pv1)=0 v(pv2)=0 v(pv3)=0 v(pv4)=0
.nodeset v(IO_iovdd)=3.3 v(IO_vdd)=1.2 v(IO_vss)=0 v(IO_iovss)=0


* OP Parameters & Singals to save
.save V(vout) V(vcont) V(iv4) V(iv3) V(iv2) V(iv1) V(iv0) V(pv4) V(pv3) V(pv2) V(pv1) V(pv0) V(x1.vsq[2]) V(x1.vsq[1]) V(x1.vsq[0]) V(x1.vst[7]) V(x1.vst[6]) V(x1.vst[5]) V(x1.vst[4]) V(x1.vst[3]) V(x1.vst[2]) V(x1.vst[1]) V(x1.vstq[7]) V(x1.vstq[6]) V(x1.vstq[5]) V(x1.vstq[4]) V(x1.vstq[3]) V(x1.vstq[2]) V(x1.vstq[1]) V(x1.vi) V(x1.vib) V(x1.vq) V(x1.vqb)
*.save V(vout) V(x1.voutpi) V(x1.voutdiv) V(iv4) V(iv3) V(iv2) V(iv1) V(iv0) V(pv4) V(pv3) V(pv2) V(pv1) V(pv0) V(pvout) V(x1.x1.vsq[2]) V(x1.x1.vsq[1]) V(x1.x1.vsq[0]) V(x1.x1.vst[7]) V(x1.x1.vst[6]) V(x1.x1.vst[5]) V(x1.x1.vst[4]) V(x1.x1.vst[3]) V(x1.x1.vst[2]) V(x1.x1.vst[1]) V(x1.x1.vstq[7]) V(x1.x1.vstq[6]) V(x1.x1.vstq[5]) V(x1.x1.vstq[4]) V(x1.x1.vstq[3]) V(x1.x1.vstq[2]) V(x1.x1.vstq[1]) V(x1.x1.vi) V(x1.x1.vib) V(x1.x1.vq) V(x1.x1.vqb)


*Simulations
.control
set ngdebug
set verbose
let simul = 0
while simul < 32
	echo Simulando la fase $&simul
	alterparam b0 = $&simul%2
	alterparam b1 = floor($&simul/2)%2
	alterparam b2 = floor($&simul/4)%2
	alterparam b3 = floor($&simul/8)%2
	alterparam b4 = floor($&simul/16)%2
	reset
	tran 5PS 20NS
	display
	set filetype = ascii
	write tran_io_fase\{$&simul\}.raw
	let simul = simul+1
	end
.endc
.end"}
C {lab_pin.sym} 90 -960 2 0 {name=p23 sig_type=std_logic lab=IO_iovdd}
C {project_io/sg13g2_IOPadIOVdd/sg13g2_IOPadIOVdd.sym} 40 -840 3 0 {name=x3}
C {project_io/sg13g2_IOPadIOVss/sg13g2_IOPadIOVss.sym} 40 -40 1 0 {name=x4}
C {sg13g2_pr/bondpad.sym} 620 -470 1 0 {name=X8
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
spice_ignore=true}
C {sg13g2_pr/bondpad.sym} 40 -1020 0 0 {name=X9
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {vsource.sym} -520 -960 0 0 {name=V2 value=3.3
}
C {gnd.sym} -520 -930 0 0 {name=l5 lab=GND}
C {lab_pin.sym} -520 -1000 1 0 {name=p31 sig_type=std_logic lab=IO_iovdd}
C {vsource.sym} -720 -960 0 0 {name=V4 value=0 savecurrent=false}
C {gnd.sym} -720 -930 0 0 {name=l8 lab=GND}
C {lab_pin.sym} -720 -1000 1 0 {name=p35 sig_type=std_logic lab=IO_iovss}
C {project_io/sg13g2_IOPadVdd/sg13g2_IOPadVdd.sym} -40 -840 3 0 {name=x5}
C {sg13g2_pr/bondpad.sym} -40 -1020 0 0 {name=X6
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {vsource.sym} -580 -960 0 0 {name=V1 value=1.2}
C {gnd.sym} -580 -930 0 0 {name=l3 lab=GND}
C {lab_pin.sym} -580 -1000 1 0 {name=p17 sig_type=std_logic lab=IO_vdd}
C {vsource.sym} -660 -960 0 0 {name=V3 value=0 savecurrent=false}
C {gnd.sym} -660 -930 0 0 {name=l7 lab=GND}
C {lab_pin.sym} -660 -1000 1 0 {name=p25 sig_type=std_logic lab=IO_vss}
C {project_io/sg13g2_IOPadVSS/sg13g2_IOPadVSS.sym} -40 -40 1 0 {name=x10}
C {lab_pin.sym} -100 -960 0 0 {name=p26 sig_type=std_logic lab=IO_vdd}
C {sg13g2_pr/bondpad.sym} 40 160 2 0 {name=X11
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -40 160 2 0 {name=X14
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {lab_pin.sym} 100 100 2 0 {name=p29 sig_type=std_logic lab=IO_iovss}
C {lab_pin.sym} -100 100 0 0 {name=p34 sig_type=std_logic lab=IO_vss}
C {project_io/sg13g2_IOPadIn/sg13g2_IOPadIn.sym} -500 -650 0 1 {name=x13}
C {project_io/sg13g2_IOPadIn/sg13g2_IOPadIn.sym} -500 -570 0 1 {name=x16}
C {project_io/sg13g2_IOPadIn/sg13g2_IOPadIn.sym} -500 -490 0 1 {name=x17}
C {project_io/sg13g2_IOPadIn/sg13g2_IOPadIn.sym} -500 -410 0 1 {name=x18}
C {project_io/sg13g2_IOPadIn/sg13g2_IOPadIn.sym} -500 -330 0 1 {name=x19}
C {project_io/sg13g2_IOPadAnalog/sg13g2_IOPadAnalog.sym} -500 -250 0 1 {name=x20}
C {lab_pin.sym} -670 -650 1 0 {name=p19 sig_type=std_logic lab=iv4}
C {devices/lab_pin.sym} -670 -250 1 0 {name=p15 sig_type=std_logic lab=vcont}
C {lab_pin.sym} -670 -570 1 0 {name=p24 sig_type=std_logic lab=iv3
}
C {lab_pin.sym} -670 -490 1 0 {name=p32 sig_type=std_logic lab=iv2}
C {lab_pin.sym} -670 -410 1 0 {name=p33 sig_type=std_logic lab=iv1}
C {lab_pin.sym} -670 -330 1 0 {name=p36 sig_type=std_logic lab=iv0}
C {lab_pin.sym} -300 -650 2 0 {name=p37 sig_type=std_logic lab=pv4}
C {lab_pin.sym} -300 -570 2 0 {name=p38 sig_type=std_logic lab=pv3}
C {lab_pin.sym} -300 -490 2 0 {name=p39 sig_type=std_logic lab=pv2}
C {lab_pin.sym} -300 -410 2 0 {name=p40 sig_type=std_logic lab=pv1}
C {lab_pin.sym} -300 -330 2 0 {name=p41 sig_type=std_logic lab=pv0}
C {devices/lab_pin.sym} 180 -480 1 0 {name=p27 sig_type=std_logic lab=vout
}
C {sg13g2_pr/bondpad.sym} -790 -650 3 0 {name=X7
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -790 -570 3 0 {name=X12
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -790 -490 3 0 {name=X21
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -790 -410 3 0 {name=X22
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -790 -330 3 0 {name=X23
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {sg13g2_pr/bondpad.sym} -790 -250 3 0 {name=X24
model=bondpad
spiceprefix=X
size=80u
shape=0
padtype=0
}
C {devices/code_shown.sym} -1740 -960 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value="
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.include diodes.lib
.include sg13g2_bondpad.lib
"}
C {capa.sym} 560 -420 0 0 {name=C1
m=1
value=25f
footprint=1206
device="ceramic capacitor"
spice_ignore=true}
C {project_io/sg13g2_IOPadOut4mA/sg13g2_IOPadOut4mA.sym} 420 -470 0 0 {name=x25
spice_ignore=true}
C {8xPI_top/8xPI_top.sym} -260 -250 0 0 {name=x1
}
C {inv/inv.sym} 20 -460 1 0 {name=x2
}
C {capa.sym} 160 -260 0 0 {name=C2
m=1
value=50f
footprint=1206
device="ceramic capacitor"
}
C {devices/lab_pin.sym} 560 -480 1 0 {name=p1 sig_type=std_logic lab=pvout
spice_ignore=true}
